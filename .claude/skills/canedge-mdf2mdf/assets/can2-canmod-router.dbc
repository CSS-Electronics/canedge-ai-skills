VERSION ""


NS_ :
    NS_DESC_
    CM_
    BA_DEF_
    BA_
    VAL_
    CAT_DEF_
    CAT_
    FILTER
    BA_DEF_DEF_
    EV_DATA_
    ENVVAR_DATA_
    SGTYPE_
    SGTYPE_VAL_
    BA_DEF_SGTYPE_
    BA_SGTYPE_
    SIG_TYPE_REF_
    VAL_TABLE_
    SIG_GROUP_
    SIG_VALTYPE_
    SIGTYPE_VALTYPE_
    BO_TX_BU_
    BA_DEF_REL_
    BA_REL_
    BA_DEF_DEF_REL_
    BU_SG_REL_
    BU_EV_REL_
    BU_BO_REL_
    SG_MUL_VAL_

BS_:

BU_:


BO_ 16 Router: 0 Vector__XXX

BO_ 18 Router: 0 Vector__XXX


BA_DEF_  "BusType" STRING ;
BA_DEF_  "ProtocolType" STRING ;
BA_DEF_ BO_  "TransportProtocolType" STRING ;
BA_DEF_ BO_  "MessageIgnore" INT 0 1;
BA_DEF_ SG_  "SignalIgnore" INT 0 1;

BA_DEF_DEF_  "BusType" "";
BA_DEF_DEF_  "ProtocolType" "";
BA_DEF_DEF_  "TransportProtocolType" "";
BA_DEF_DEF_  "MessageIgnore" 0;
BA_DEF_DEF_  "SignalIgnore" 0;

BA_ "BusType" "CAN";
BA_ "TransportProtocolType" BO_ 16 "MUXTP#11:12:13:14";
BA_ "TransportProtocolType" BO_ 18 "MUXTP#15:16:17:18";

